# Keil uVision project project.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: R7FA8D1BH Renesas
  pack: Renesas.RA_DFP.5.1.0
  cpu: IRAM(0x22000000,0xE0000) IRAM2(0x0,0x10000) IROM(0x02000000,0x001F8000) XRAM(0x20000000,0x10000) CPUTYPE("Cortex-M85") FPU3(DFPU) DSP TZ MVE(FP) PACBTI CLOCK(12000000) ELITTLE
  output: rtthread +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c define: __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, ARM_MATH_CM85, __FPU_PRESENT = 1, NDEBUG, RT_USING_LIBC, MICROPY_PY_DISPLAY = 1, CMSIS_NN, __CLK_TCK=RT_TICK_PER_SECOND, TF_LITE_STATIC_MEMORY, __RTTHREAD__, MICROPY_PY_SENSOR = 1
  c misc: -Wno-license-management -Wuninitialized -Wall -Wmissing-declarations -Wpointer-arith -Waggregate-return -Wfloat-equal
  c include: rt-thread\components\dfs\dfs_v1\include;packages\micropython-v1.13.0\port\modules;packages\OpenMV-v4.5.0\src\omv\alloc;.;board\ports\tf-micro\third_party\flatbuffers\include;rt-thread\components\net\lwip\lwip-2.0.3\src\include\netif;board\ports\tf-micro\third_party\kissfft;rt-thread\components\net\lwip\lwip-2.0.3\src\include;rt-thread\components\net\sal\include\dfs_net;board\ports\mipi_lcd;board\ports;board\ports\tf-micro\signal\src\kiss_fft_wrappers;rt-thread\components\fal\inc;board\ports\tf-micro\libtf;rt-thread\components\drivers\include;packages\OpenMV-v4.5.0\src\hal;packages\OpenMV-v4.5.0\src\omv;rt-thread\components\drivers\include;rt-thread\components\libc\compilers\common\include;packages\rw007-v2.1.0;packages\OpenMV-v4.5.0\src\omv\ports\ra8;packages\OpenMV-v4.5.0\src\omv\modules;board\ports\CMSIS-NN;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\net\sal\impl;packages\micropython-v1.13.0\ports\renesas\boards\EK-RA8D1;board\ports\scc8660;rt-thread\components\drivers\include;packages\OpenMV-v4.5.0;board\ports\wifi;board\ports\tf-micro;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\scipy\linalg;rt-thread\components\drivers\include;packages\rw007-v2.1.0\inc;rt-thread\components\net\sal\include\socket\sys_socket;rt-thread\components\libc\posix\ipc;packages\OpenMV-v4.5.0\src\hal\cmsis\include;packages\CmBacktrace-v1.4.1;board\ports\tf-micro\third_party\gemmlowp;rt-thread\components\drivers\include;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\numpy\carray;packages\tinyusb\src;board\ports\tf-micro\third_party\ruy;rt-thread\components\net\sal\include;rt-thread\components\libc\posix\io\eventfd;rt-thread\components\net\sal\include\socket;packages\OpenMV-v4.5.0\src\omv\boards\RA8;packages\micropython-v1.13.0\port\modules\machine;rt-thread\components\net\lwip\port;rt-thread\libcpu\arm\common;rt-thread\components\libc\posix\io\poll;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\numpy\fft;rt-thread\components\libc\compilers\common\extension;packages\micropython-v1.13.0\py;board\ports\CMSIS-NN\Include\Internal;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\numpy\ndarray;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\user;rt-thread\components\net\lwip\lwip-2.0.3\src\include\ipv4;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\components\dfs\dfs_v1\filesystems\elmfat;rt-thread\components\net\lwip-dhcpd;rt-thread\components\finsh;rt-thread\components\drivers\wlan;board;packages\OpenMV-v4.5.0\src\omv\common;board\ports\omv_fs;rt-thread\components\libc\posix\io\epoll;board\ports\tf-micro\signal\src;rt-thread\components\net\netdev\include;rt-thread\components\dfs\dfs_v1\filesystems\devfs;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\numpy;libraries\HAL_Drivers;rt-thread\include;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\numpy\linalg;packages\micropython-v1.13.0\ports\renesas;packages\micropython-v1.13.0\lib\utils;rt-thread\components\drivers\spi;rt-thread\components\drivers\include;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\scipy\special;libraries\HAL_Drivers\config;rt-thread\components\drivers\include;packages\micropython-v1.13.0;packages\micropython-v1.13.0\port;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code;packages\OpenMV-v4.5.0\src\lib\libtf;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\scipy\signal;rt-thread\components\drivers\include;board\ports\tf-micro\signal\micro\kernels;board\ports\CMSIS-NN\Include;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\utils;packages\tinyusb\lib\rt-thread;packages\OpenMV-v4.5.0\src\omv\sensors;packages\OpenMV-v4.5.0\src\omv\imlib;rt-thread\components\libc\cplusplus;rt-thread\libcpu\arm\cortex-m85;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\scipy\optimize;packages\micropython-v1.13.0\lib\libm_dbl
  library: MicroLIB
  memory RVCT4: ROM 0x2000000 size 0x1f8000
  memory RVCT6: RAM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x22000000 size 0xe0000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: .\script\fsp.scat
  group cm_backtrace
    packages/CmBacktrace-v1.4.1/: cmb_flash_log.c cmb_port.c cm_backtrace.c
  group CMSIS_NN
    board/ports/CMSIS-NN/Source/ActivationFunctions/: arm_relu_q15.c arm_relu_q7.c arm_nn_activation_s16.c arm_relu6_s8.c
    board/ports/CMSIS-NN/Source/ConvolutionFunctions/: arm_convolve_1x1_s8_fast.c arm_depthwise_conv_get_buffer_sizes_s8.c arm_convolve_1x1_s4_fast.c arm_nn_mat_mult_kernel_s8_s16.c arm_depthwise_conv_get_buffer_sizes_s16.c arm_depthwise_conv_s4_opt.c arm_depthwise_conv_fast_s16.c arm_transpose_conv_s8.c arm_convolve_s4.c arm_depthwise_conv_s8.c arm_nn_mat_mult_s8.c arm_depthwise_conv_wrapper_s16.c arm_convolve_wrapper_s4.c arm_convolve_get_buffer_sizes_s16.c arm_convolve_1x1_s4.c arm_convolve_wrapper_s16.c arm_depthwise_conv_s16.c arm_convolve_1x1_s8.c arm_depthwise_conv_3x3_s8.c arm_transpose_conv_get_buffer_sizes_s8.c arm_convolve_s8.c arm_depthwise_conv_wrapper_s4.c arm_depthwise_conv_wrapper_s8.c arm_convolve_fast_s16.c arm_convolve_get_buffer_sizes_s8.c arm_depthwise_conv_s8_opt.c arm_depthwise_conv_s4.c arm_nn_depthwise_conv_s8_core.c arm_depthwise_conv_get_buffer_sizes_s4.c arm_convolve_get_buffer_sizes_s4.c arm_convolve_1_x_n_s8.c arm_convolve_s16.c arm_convolve_wrapper_s8.c arm_nn_mat_mult_kernel_s4_s16.c
    board/ports/CMSIS-NN/Source/NNSupportFunctions/: arm_nn_vec_mat_mult_t_s16.c arm_nn_lstm_update_cell_state_s16.c arm_nn_mat_mul_kernel_s16.c arm_nn_vec_mat_mult_t_s4.c arm_nn_depthwise_conv_nt_t_padded_s8.c arm_nn_depthwise_conv_nt_t_s8.c arm_nn_vec_mat_mul_result_acc_s8.c arm_nn_vec_mat_mult_t_svdf_s8.c arm_nn_mat_mul_core_1x_s8.c arm_q7_to_q15_with_offset.c arm_nn_depthwise_conv_nt_t_s16.c arm_nn_mat_mult_nt_t_s4.c arm_nntables.c arm_nn_lstm_step_s8_s16.c arm_nn_mat_mult_nt_t_s8_s32.c arm_nn_mat_mul_core_4x_s8.c arm_nn_lstm_update_output_s8_s16.c arm_nn_mat_mult_nt_t_s8.c arm_nn_lstm_calculate_gate_s8_s16.c arm_s8_to_s16_unordered_with_offset.c arm_nn_vec_mat_mult_t_s8.c
    board/ports/CMSIS-NN/Source/FullyConnectedFunctions/: arm_fully_connected_get_buffer_sizes_s16.c arm_fully_connected_s8.c arm_fully_connected_s16.c arm_vector_sum_s8.c arm_fully_connected_get_buffer_sizes_s8.c arm_fully_connected_s4.c
    board/ports/CMSIS-NN/Source/SVDFunctions/: arm_svdf_s8.c arm_svdf_get_buffer_sizes_s8.c arm_svdf_state_s16_s8.c
    board/ports/CMSIS-NN/Source/BasicMathFunctions/: arm_elementwise_mul_s8.c arm_elementwise_add_s16.c arm_elementwise_mul_s16.c arm_elementwise_mul_s16_s8.c arm_elementwise_add_s8.c
    board/ports/CMSIS-NN/Source/PoolingFunctions/: arm_max_pool_s16.c arm_avgpool_get_buffer_sizes_s8.c arm_avgpool_s8.c arm_avgpool_s16.c arm_max_pool_s8.c arm_avgpool_get_buffer_sizes_s16.c
    board/ports/CMSIS-NN/Source/SoftmaxFunctions/: arm_softmax_s8.c arm_softmax_s8_s16.c arm_softmax_u8.c arm_nn_softmax_common_s8.c arm_softmax_s16.c
    board/ports/CMSIS-NN/Source/ConcatenationFunctions/: arm_concatenation_s8_y.c arm_concatenation_s8_x.c arm_concatenation_s8_z.c arm_concatenation_s8_w.c
    board/ports/CMSIS-NN/Source/ReshapeFunctions/: arm_reshape_s8.c
    board/ports/CMSIS-NN/Source/LSTMFunctions/: arm_lstm_unidirectional_s8_s16.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group CPP
    rt-thread/components/libc/cplusplus/: cxx_crt.cpp cxx_crt_init.c
  group CPU
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m85/: context_gcc.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/hwtimer/: hwtimer.c
    rt-thread/components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c rt_drv_pwm.c
    rt-thread/components/drivers/mtd/: mtd_nor.c
    rt-thread/components/drivers/rtc/: rtc.c soft_rtc.c
    rt-thread/components/drivers/sdio/: block_dev.c gpt.c mmc.c mmcsd_core.c sd.c sdio.c
    rt-thread/components/drivers/serial/: serial_v2.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
    rt-thread/components/drivers/wlan/: wlan_cfg.c wlan_cmd.c wlan_dev.c wlan_lwip.c wlan_mgnt.c wlan_prot.c wlan_workqueue.c
  group Drivers
    board/ports/: drv_sdram.c mnt.c
    board/ports/mipi_lcd/: mipi_config.c
    board/ports/wifi/: drv_rw007.c
    board/: ra8_it.c
    libraries/HAL_Drivers/: drv_common.c drv_flash.c drv_gpio.c drv_lcd.c drv_pwm.c drv_sci.c drv_sdhi.c drv_soft_i2c.c drv_spi.c drv_usart_v2.c
  group Fal
    rt-thread/components/fal/src/: fal_rtt.c fal_flash.c fal_partition.c fal.c
  group Filesystem
    rt-thread/components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    rt-thread/components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_up.c thread.c timer.c
  group lwIP
    rt-thread/components/net/lwip-dhcpd/: dhcp_server_raw.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c lowpan6.c
    rt-thread/components/net/lwip/port/: ethernetif.c sys_arch.c
  group micropython
    packages/micropython-v1.13.0/extmod/: machine_spi.c utime_mphal.c moduzlib.c modbtree.c vfs.c moduhashlib.c modussl_axtls.c vfs_fat.c modujson.c vfs_posix.c moducryptolib.c virtpin.c moduselect.c vfs_fat_diskio.c modure.c modwebsocket.c machine_i2c.c modframebuf.c vfs_posix_file.c machine_mem.c modonewire.c moductypes.c machine_pinbase.c vfs_reader.c machine_pulse.c moduwebsocket.c modubinascii.c moduheapq.c machine_signal.c modussl_mbedtls.c modurandom.c uos_dupterm.c modwebrepl.c modutimeq.c vfs_fat_file.c
    packages/micropython-v1.13.0/py/: modthread.c frozenmod.c stackctrl.c builtinimport.c objmodule.c emitnxtensa.c runtime.c mpstate.c scheduler.c objnone.c objcell.c objzip.c scope.c nlr.c objnamedtuple.c ringbuf.c reader.c binary.c nlrthumb.c objslice.c objsingleton.c objint_longlong.c asmxtensa.c parsenumbase.c modsys.c objenumerate.c builtinevex.c objint_mpz.c argcheck.c omvdummy.c stream.c asmthumb.c nlrpowerpc.c mpz.c objint.c builtinhelp.c modmath.c objfun.c qstr.c nlraarch64.c asmbase.c nativeglue.c modio.c asmarm.c objgetitemiter.c objdeque.c objset.c emitnx86.c pairheap.c objstrunicode.c opmethods.c objpolyiter.c objmap.c formatfloat.c parsenum.c modmicropython.c objfilter.c objboundmeth.c emitglue.c modstruct.c objproperty.c objcomplex.c gc.c objstringio.c repl.c persistentcode.c mpprint.c nlrsetjmp.c malloc.c parse.c nlrmips.c nlrx64.c lexer.c vm.c objlist.c obj.c objfloat.c emitnxtensawin.c unicode.c nlrx86.c objrange.c objclosure.c warning.c modbuiltins.c nlrxtensa.c map.c objbool.c objarray.c emitinlinethumb.c objreversed.c compile.c objtype.c asmx86.c asmx64.c showbc.c objgenerator.c emitbc.c sequence.c profile.c modgc.c objstr.c modarray.c vstr.c objattrtuple.c objtuple.c emitinlinextensa.c runtime_utils.c pystack.c objobject.c emitnthumb.c emitcommon.c modcollections.c modcmath.c objexcept.c bc.c emitnative.c smallint.c moduerrno.c objdict.c emitnx64.c emitnarm.c
    packages/micropython-v1.13.0/lib/mp-readline/: readline.c
    packages/micropython-v1.13.0/lib/timeutils/: timeutils.c
    packages/micropython-v1.13.0/lib/netutils/: netutils.c
    packages/micropython-v1.13.0/lib/utils/: printf.c pyexec.c stdout_helpers.c interrupt_char.c sys_stdio_mphal.c mpirq.c
    packages/micropython-v1.13.0/drivers/bus/: softspi.c softqspi.c
  group micropython/machine
    packages/micropython-v1.13.0/port/modules/machine/: machine_hw_i2c.c machine_timer.c modmachine.c machine_uart.c machine_rtc.c machine_lcd.c machine_hw_spi.c machine_pwm.c machine_adc.c machine_wdt.c machine_pin.c
  group micropython/modules
    packages/micropython-v1.13.0/port/modules/: modrtthread.c moduos.c modnetwork.c moduos_file.c modffi.c modnetwork_wlan.c modutils.c modutime.c modusocket.c modpyb.c modfile.c
    packages/micropython-v1.13.0/port/: gccollect.c mpy_main.c mpputsnport.c mphalport.c mpthreadport.c frozen_mpy.c mpgetcharport.c
    packages/micropython-v1.13.0/port/native/: easyflash_module.c native_module.c
    packages/micropython-v1.13.0/port/modules/user/: moduserfunc.c
  group micropython/ra-port
    packages/micropython-v1.13.0/ports/renesas/: pyb_uart.c pyb_i2c.c bufhelper.c tinyusb_debug.c led.c machine_led.c
  group openmv/alloc
    packages/OpenMV-v4.5.0/src/omv/alloc/: unaligned_memcpy.c xalloc.c umm_malloc.c dma_alloc.c fb_alloc.c
  group openmv/common
    packages/OpenMV-v4.5.0/src/omv/common/: sensor_utils.c usbdbg.c trace.c vospi.c factoryreset.c ringbuf.c array.c mutex.c
  group openmv/dsp
    packages/OpenMV-v4.5.0/src/hal/cmsis/src/dsp/FastMathFunctions/: arm_sin_q15.c arm_sin_q31.c arm_sqrt_q15.c arm_cos_f32.c arm_cos_q15.c arm_cos_q31.c arm_sin_f32.c arm_sqrt_q31.c
    packages/OpenMV-v4.5.0/src/hal/cmsis/src/dsp/TransformFunctions/: arm_rfft_init_q31.c arm_rfft_init_q15.c
    packages/OpenMV-v4.5.0/src/hal/cmsis/src/dsp/CommonTables/: arm_common_tables.c arm_const_structs.c
  group openmv/imlib
    packages/OpenMV-v4.5.0/src/omv/imlib/: draw.c agast.c pool.c mathop.c integral_mw.c hough.c jpeg.c selective_search.c bmp.c phasecorrelation.c zbar.c bayer.c jpegd.c fmath.c ppm.c apriltag.c qsort.c yuv.c isp.c lsd.c edge.c stereo.c rainbow_tab.c clahe.c collections.c line.c template.c fft.c integral.c imlib.c lab_tab.c binary.c font.c rectangle.c xyz_tab.c png.c lbp.c dmtx.c sincos_tab.c mjpeg.c point.c blob.c kmeans.c hog.c gif.c orb.c filter.c qrcode.c fast.c eye.c lodepng.c haar.c framebuffer.c stats.c fsort.c
  group openmv/modules
    packages/OpenMV-v4.5.0/src/omv/modules/: py_omv.c py_helper.c py_tf.c py_gif.c py_mjpeg.c py_spi_display.c py_clock.c py_image.c py_sensor.c py_imageio.c py_display.c
  group openmv/port/ra8
    packages/OpenMV-v4.5.0/src/omv/ports/ra8/: cambus.c omv_gpio.c omv_lcd.c sensor.c
  group openmv/rtt-port
    board/ports/omv_fs/: ff_wrapper.c
  group openmv/sensor
    packages/OpenMV-v4.5.0/src/omv/sensors/: paj6100.c ov9650.c hm01b0.c ov2640.c ov7670.c lepton.c ov7725.c ov7690.c gc0328.c mt9v0xx.c hm0360.c gc2145.c scc8660.c ov5640.c frogeye2020.c mt9m114.c
  group openmv/ulab
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/: ulab_tools.c ndarray_properties.c ulab.c ndarray.c ndarray_operators.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/numpy/fft/: fft_tools.c fft.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/numpy/ndarray/: ndarray_iter.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/user/: user.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/numpy/linalg/: linalg.c linalg_tools.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/numpy/: stats.c numpy.c approx.c filter.c numerical.c transform.c compare.c poly.c vector.c create.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/numpy/carray/: carray_tools.c carray.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/utils/: utils.c
  group openmv/ulab/scipy
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/scipy/optimize/: optimize.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/scipy/special/: special.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/scipy/signal/: signal.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/scipy/: scipy.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/scipy/linalg/: linalg.c
  group POSIX
    rt-thread/components/libc/posix/io/poll/: poll.c select.c
  group rw007
    packages/rw007-v2.1.0/src/: spi_wifi_rw007.c
  group SAL
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
    rt-thread/components/net/sal/dfs_net/: dfs_net.c
    rt-thread/components/net/sal/impl/: af_inet_lwip.c
    rt-thread/components/net/sal/socket/: net_netdb.c net_sockets.c
    rt-thread/components/net/sal/src/: sal_socket.c
  group tensorflow
    board/ports/tf-micro/tensorflow/lite/kernels/internal/: common.cpp portable_tensor_utils.cpp tensor_utils.cpp tensor_ctypes.cpp quantization_util.cpp
    board/ports/tf-micro/tensorflow/lite/core/api/: flatbuffer_conversions.cpp error_reporter.cpp tensor_utils.cpp
    board/ports/tf-micro/tensorflow/lite/micro/memory_planner/: linear_memory_planner.cpp greedy_memory_planner.cpp
    board/ports/tf-micro/tensorflow/lite/micro/arena_allocator/: non_persistent_arena_buffer_allocator.cpp single_arena_buffer_allocator.cpp persistent_arena_buffer_allocator.cpp recording_single_arena_buffer_allocator.cpp
    board/ports/tf-micro/tensorflow/lite/kernels/internal/reference/: comparisons.cpp portable_tensor_utils.cpp
    board/ports/tf-micro/tensorflow/lite/core/c/: common.cpp
    board/ports/tf-micro/tensorflow/lite/kernels/: kernel_util.cpp
    board/ports/tf-micro/tensorflow/lite/schema/: schema_utils.cpp
  group tensorflow/cmsis_nn
    board/ports/tf-micro/tensorflow/lite/micro/kernels/cmsis_nn/: fully_connected.cpp pooling.cpp softmax.cpp mul.cpp svdf.cpp add.cpp depthwise_conv.cpp conv.cpp
  group tensorflow/kernels
    board/ports/tf-micro/tensorflow/lite/micro/kernels/: neg.cpp lstm_eval.cpp dequantize.cpp gather_nd.cpp l2_pool_2d.cpp shape.cpp prelu.cpp concatenation.cpp unpack.cpp resize_nearest_neighbor.cpp sub.cpp while.cpp broadcast_args.cpp fill.cpp transpose_conv.cpp space_to_depth.cpp var_handle.cpp kernel_util.cpp reshape_common.cpp strided_slice_common.cpp squared_difference.cpp dequantize_common.cpp ethosu.cpp reduce_common.cpp depthwise_conv_common.cpp gather.cpp quantize.cpp round.cpp assign_variable.cpp cumsum.cpp zeros_like.cpp slice.cpp softmax_common.cpp div.cpp floor_div.cpp logical.cpp reshape.cpp read_variable.cpp leaky_relu.cpp activations.cpp conv_common.cpp space_to_batch_nd.cpp call_once.cpp squeeze.cpp leaky_relu_common.cpp log_softmax.cpp mul_common.cpp elementwise.cpp fully_connected_common.cpp cast.cpp exp.cpp pad.cpp batch_to_space_nd.cpp micro_tensor_utils.cpp sub_common.cpp if.cpp split.cpp logistic_common.cpp logistic.cpp circular_buffer.cpp circular_buffer_common.cpp activations_common.cpp elu.cpp floor.cpp batch_matmul.cpp split_v.cpp maximum_minimum.cpp embedding_lookup.cpp l2norm.cpp reduce.cpp expand_dims.cpp tanh.cpp add_common.cpp pooling_common.cpp comparisons.cpp logical_common.cpp mirror_pad.cpp depth_to_space.cpp hard_swish.cpp transpose.cpp select.cpp prelu_common.cpp broadcast_to.cpp unidirectional_sequence_lstm.cpp arg_min_max.cpp svdf_common.cpp quantize_common.cpp detection_postprocess.cpp ceil.cpp lstm_eval_common.cpp strided_slice.cpp resize_bilinear.cpp floor_mod.cpp pack.cpp hard_swish_common.cpp add_n.cpp kernel_runner.cpp
    board/ports/tf-micro/tensorflow/lite/micro/cortex_m_generic/: debug_log.cpp micro_time.cpp
  group tensorflow/lib
    board/ports/tf-micro/libtf/: libtf_builtin_models.c libtf.cpp
  group tensorflow/micro
    board/ports/tf-micro/tensorflow/lite/micro/: micro_interpreter_context.cpp micro_utils.cpp test_helpers.cpp micro_context.cpp micro_interpreter_graph.cpp micro_allocation_info.cpp test_helper_custom_ops.cpp micro_interpreter.cpp fake_micro_context.cpp recording_micro_allocator.cpp micro_op_resolver.cpp micro_profiler.cpp memory_helpers.cpp flatbuffer_utils.cpp micro_allocator.cpp micro_resource_variable.cpp micro_log.cpp system_setup.cpp mock_micro_graph.cpp
    board/ports/tf-micro/tensorflow/lite/micro/tflite_bridge/: flatbuffer_conversions_bridge.cpp micro_error_reporter.cpp
  group tensorflow/signal
    board/ports/tf-micro/signal/src/: msb_32.cpp overlap_add.cpp irfft_float.cpp circular_buffer.cpp window.cpp filter_bank_square_root.cpp irfft_int32.cpp square_root_32.cpp energy.cpp filter_bank_log.cpp filter_bank.cpp max_abs.cpp pcan_argc_fixed.cpp log.cpp square_root_64.cpp fft_auto_scale.cpp irfft_int16.cpp rfft_int32.cpp msb_64.cpp filter_bank_spectral_subtraction.cpp rfft_int16.cpp rfft_float.cpp
    board/ports/tf-micro/signal/micro/kernels/: irfft.cpp rfft.cpp filter_bank_log.cpp energy.cpp framer.cpp filter_bank.cpp fft_auto_scale_common.cpp filter_bank_square_root_common.cpp delay.cpp fft_auto_scale_kernel.cpp filter_bank_square_root.cpp pcan.cpp stacker.cpp overlap_add.cpp filter_bank_spectral_subtraction.cpp window.cpp
    board/ports/tf-micro/signal/src/kiss_fft_wrappers/: kiss_fft_int16.cpp kiss_fft_int32.cpp kiss_fft_float.cpp
  group TinyUSB
    board/tinyusb/: drv_tinyusb.c usb_descriptors.c
    packages/tinyusb/src/class/cdc/: cdc_device.c
    packages/tinyusb/src/common/: tusb_fifo.c
    packages/tinyusb/src/device/: usbd.c usbd_control.c
    packages/tinyusb/src/portable/renesas/rusb2/: dcd_rusb2.c rusb2_common.c
    packages/tinyusb/src/: tusb.c
    packages/tinyusb/lib/rt-thread/: tusb_rt_thread_port.c
  group WICED
    board/ports/scc8660/: scc8660.lib
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
software components: Flex Software:RA Configuration 1.0.0
